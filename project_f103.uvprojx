# Keil uVision project project_f103.uvprojx, settings and files
target project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project_f103
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Core;.\Drivers\inc;.\Drivers\src;.\StartUp;.\UserSourse;.\System;..\project
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group UserSourse
    ./UserSourse/: delayms.c delayms.h i2c.c i2c.h init.c init.h main.c stm32f10x_conf.h htu21.c htu21.h motor_28byj_48.h motor_28byj_48.c main.h
  group Core
    ./Core/: core_cm3.c core_cm3.h
  group Drivers
    ./Drivers/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Systems
    ./System/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group StartUp
    ./StartUp/: startup_stm32f10x_md.s
